# Keil uVision project main.uvproj, settings and files
target Target 1 (MCS-51)
  device: MPC89E58 Megawin
  cpu: IRAM(0 - 0xFF) XRAM(0x0-0x3FF) IROM(0 - 0x7FFF) CLOCK(45000000)
  output: main
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c
    ../HelloWorld/: MPCx58AP.h

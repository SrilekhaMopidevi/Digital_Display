# Keil uVision project SerialTest.uvproj, settings and files
target Target 1 (MCS-51)
  device: MPC89E54 Megawin
  cpu: IRAM(0 - 0xFF) XRAM(0x0-0x3FF) IROM(0 - 0x3FFF) CLOCK(45000000)
  output: SerialTest +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c MPCx58AP.h
